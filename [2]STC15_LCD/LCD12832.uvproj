# Keil uVision project LCD12832.uvproj, settings and files
target STC15W408AS (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: LCD12832 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LCD
  group Main
    ./: STARTUP.A51 main.c
  group LCD
    ./LCD/: kfm010b11.C
